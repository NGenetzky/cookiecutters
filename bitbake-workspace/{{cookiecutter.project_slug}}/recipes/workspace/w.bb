inherit delclass_oe_base

do_build(){
    env > build.env.sh
}
